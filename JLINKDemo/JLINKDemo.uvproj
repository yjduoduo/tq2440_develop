# Keil uVision project JLINKDemo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: JLINKDemo +hex
  AfterMake: fromelf.exe --bin -o @p.bin output/@p.axf
  c flags: Optim=1
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x200000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group Source Group 1
    ./: S3C2440.s mian.c
